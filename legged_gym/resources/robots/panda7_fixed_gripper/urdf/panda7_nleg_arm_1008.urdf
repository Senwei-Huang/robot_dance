Commit message: urdf

File: legged_gym/resources/robots/panda7_fixed_gripper/urdf/panda7_nleg_arm_1008.urdf (robot description, URDF)
Before this commit: robot robot, 27 links, 26 joints
Links:
- link base: mass 101.377848 -> 41.377848
